v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -260 -450 0 0 {name=p1 lab=clk}
C {ipin.sym} -260 -420 0 0 {name=p2 lab=rst_n}
C {ipin.sym} -260 -390 0 0 {name=p3 lab=start}
C {ipin.sym} -260 -360 0 0 {name=p4 lab=comp_out}
C {opin.sym} -110 -450 0 0 {name=p5 lab=samp_top}
C {opin.sym} -110 -420 0 0 {name=p6 lab=samp_bot}
C {opin.sym} -110 -390 0 0 {name=p7 lab=cmp_rst}
C {opin.sym} -110 -360 0 0 {name=p8 lab=cmp_clk}
C {opin.sym} -110 -330 0 0 {name=p9 lab=dac_p[9:0]}
C {opin.sym} -110 -300 0 0 {name=p10 lab=dac_n[9:0]}
C {opin.sym} -110 -270 0 0 {name=p11 lab=busy}
C {opin.sym} -110 -240 0 0 {name=p12 lab=eoc}
C {opin.sym} -110 -210 0 0 {name=p13 lab=dout_valid}
C {opin.sym} -110 -180 0 0 {name=p14 lab=dout[9:0]}
