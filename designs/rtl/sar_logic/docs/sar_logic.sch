v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -260 -360 0 0 {name=p1 lab=rst_n}
C {opin.sym} -110 -360 0 0 {name=p2 lab=busy}
C {ipin.sym} -260 -390 0 0 {name=p3 lab=clk}
C {ipin.sym} -260 -330 0 0 {name=p4 lab=start}
C {ipin.sym} -260 -300 0 0 {name=p5 lab=comp_out}
C {opin.sym} -110 -390 0 0 {name=p6 lab=eoc}
C {opin.sym} -110 -330 0 0 {name=p7 lab=dac_out[9:0]}
C {opin.sym} -110 -300 0 0 {name=p8 lab=dout[9:0]}
C {opin.sym} -110 -270 0 0 {name=p9 lab=dout_valid}
